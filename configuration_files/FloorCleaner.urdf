Commit message: update3

File: configuration_files/FloorCleaner.urdf (robot description, URDF)
Before this commit: robot yxsk, 6 links, 5 joints
Links:
- link base_link: geometry visual cylinder length=0.06 radius=0.15
